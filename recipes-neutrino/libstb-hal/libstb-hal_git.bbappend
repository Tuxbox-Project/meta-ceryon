EXTRA_OECONF_append += " \
	--with-boxtype=hd51 \
"

