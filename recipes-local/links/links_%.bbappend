FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
		file://0004-${MACHINE_DRIVER}-input.patch \
"
