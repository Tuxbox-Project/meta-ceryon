IMAGE_INSTALL_append += " \
						gfutures-dvb-modules-hd51 \
						"