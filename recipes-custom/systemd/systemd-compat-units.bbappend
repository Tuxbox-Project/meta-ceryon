SYSTEMD_DISABLED_SYSV_SERVICES = " \
  hwclock \
  syslog.busybox \
"

